# Keil uVision project Home_Control_8_v3.0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Home_Control_8_v3.0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\APP;..\Bsp;..\Lib\inc;..\Lib\src;..\Bsp\Led;..\Bsp\SysTick;..\Bsp\usart1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ../APP/: main.c stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
  group Bsp
    ../Bsp/Led/: bsp_led.c bsp_led.h
    ../Bsp/usart1/: bsp_usart.c bsp_usart.h
    ../Bsp/SysTick/: bsp_SysTick.c bsp_SysTick.h
  group Lib
    ../Lib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
